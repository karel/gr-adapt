options:
  parameters:
    author: karel
    description: This example demonstrates the use of FO-LMS adaptive filter.
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: frequency_offsets_estimation
    output_language: python
    title: Frequency Offsets Estimaton
  states: {}

blocks:
- name: F_cfo
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,3
    label: F_cfo
    min_len: '10'
    start: '-1e3'
    step: 1e3
    stop: 1e3
    value: '0'
  states: {}
- name: F_sfo
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,3
    label: F_sfo
    min_len: '10'
    start: '-.1'
    step: '.01'
    stop: '.1'
    value: '0'
  states: {}
- name: gui_mu_cfo
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: '"CFO \u03BC"'
    min_len: '100'
    start: '0.0'
    step: '0.01'
    stop: '.01'
    value: '0.0'
  states: {}
- name: gui_mu_cir
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: '"CIR \u03BC"'
    min_len: '100'
    start: '0.00'
    step: '0.01'
    stop: '1'
    value: '0.1'
  states: {}
- name: gui_mu_sfo
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,2,1,1
    label: '"SFO \u03BC"'
    min_len: '100'
    start: '0.0'
    step: '0.01'
    stop: '.01'
    value: '0.0'
  states: {}
- name: n_taps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '512000'
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,0,1,3
    label: Step sizes
    type: string
    value: ''
  states: {}
- name: variable_qtgui_label_1
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,0,1,3
    label: Frequency offsets
    type: string
    value: ''
  states: {}
- name: variable_qtgui_label_2
  id: variable_qtgui_label
  parameters:
    gui_hint: 5,0,1,3
    label: Estimates
    type: string
    value: ''
  states: {}
- name: variable_qtgui_label_2_0
  id: variable_qtgui_label
  parameters:
    gui_hint: 7,0,1,3
    label: Controls
    type: string
    value: ''
  states: {}
- name: variable_qtgui_label_3
  id: variable_qtgui_label
  parameters:
    gui_hint: 9,0,1,3
    label: Power spectral density
    type: string
    value: ''
  states: {}
- name: variable_qtgui_push_button_reset_folms
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 8,1,1,1
    label: Reset (FO-LMS)
    pressed: 'True'
    released: 'False'
    type: bool
    value: 'False'
  states: {}
- name: variable_qtgui_push_button_reset_lms
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 8,0,1,1
    label: Reset (LMS)
    pressed: 'True'
    released: 'False'
    type: bool
    value: 'False'
  states: {}
- name: adapt_fo_lms_filter_cc_0
  id: adapt_fo_lms_filter_cc
  parameters:
    adapt: 'True'
    mu_cfo: gui_mu_cfo
    mu_cir: gui_mu_cir
    mu_sfo: gui_mu_sfo
    num_taps: n_taps
    reset: variable_qtgui_push_button_reset_folms
    samp_rate: samp_rate
  states: {}
- name: adapt_lms_filter_xx_0
  id: adapt_lms_filter_xx
  parameters:
    adapt: 'True'
    bypass: 'False'
    decimation: '1'
    filtered_input: 'True'
    first_input: 'True'
    mu: gui_mu_cir
    num_taps: n_taps
    reset: variable_qtgui_push_button_reset_lms
    skip: '0'
    type: cc
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_noise_source_x_0_0
  id: analog_noise_source_x
  parameters:
    amp: '1e-4'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Carrier frequency offset.
    freq: F_cfo
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    comment: This delay is required because of the following fractional resampler.
    delay: '3'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: samp_rate / (2 * np.pi)
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    comment: Channel and subsequently added noise.
    decim: '1'
    taps: '[1.2-1j, 0.5+0.3j, 0.3+0.4j]'
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate / 16
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate / 50
    win: window.WIN_HAMMING
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    comment: Sampling frequency offset.
    phase_shift: '0'
    resamp_ratio: samp_rate / (samp_rate + F_sfo)
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 10,0,10,3
    label1: '''Transmitted (x)'''
    label2: '''Received (d)'''
    label3: '''LMS (e)'''
    label4: '''FO-LMS (e)'''
    nconnections: '4'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    avg: '.7'
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 6,0,1,3
    label1: F_cfo
    label2: F_sfo
    max: + samp_rate / 2
    min: '- samp_rate / 2'
    name: ''
    nconnections: '2'
    type: float
    unit1: Hz
    unit2: Hz
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    comment: Known transmitted signal.
    stream_id: x
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    comment: Received signal.
    stream_id: d
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: fo-lms-error
  states: {}
- name: virtual_sink_0_1_0
  id: virtual_sink
  parameters:
    stream_id: lms-error
  states: {}
- name: virtual_sink_0_1_0_0
  id: virtual_sink
  parameters:
    stream_id: f_cfo-est
  states: {}
- name: virtual_sink_0_1_0_0_0
  id: virtual_sink
  parameters:
    stream_id: f_sfo-est
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: x
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: x
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    comment: Known transmitted signal.
    stream_id: x
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: x
  states: {}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: d
  states: {}
- name: virtual_source_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: d
  states: {}
- name: virtual_source_0_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: d
  states: {}
- name: virtual_source_0_1_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: lms-error
  states: {}
- name: virtual_source_0_1_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: fo-lms-error
  states: {}
- name: virtual_source_0_2
  id: virtual_source
  parameters:
    stream_id: f_cfo-est
  states: {}
- name: virtual_source_0_2_0
  id: virtual_source
  parameters:
    stream_id: f_sfo-est
  states: {}

connections:
- [adapt_fo_lms_filter_cc_0, '0', blocks_null_sink_1, '0']
- [adapt_fo_lms_filter_cc_0, '1', virtual_sink_0_1, '0']
- [adapt_fo_lms_filter_cc_0, '2', blocks_multiply_const_vxx_0, '0']
- [adapt_fo_lms_filter_cc_0, '3', blocks_multiply_const_vxx_0_0, '0']
- [adapt_lms_filter_xx_0, '0', blocks_null_sink_0, '0']
- [adapt_lms_filter_xx_0, '1', virtual_sink_0_1_0, '0']
- [analog_noise_source_x_0, '0', low_pass_filter_0, '0']
- [analog_noise_source_x_0_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_add_xx_0, '0', virtual_sink_0_0, '0']
- [blocks_delay_0_0, '0', mmse_resampler_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', virtual_sink_0_1_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', virtual_sink_0_1_0_0_0, '0']
- [blocks_multiply_xx_0, '0', fir_filter_xxx_0, '0']
- [blocks_throttle2_0, '0', virtual_sink_0, '0']
- [fir_filter_xxx_0, '0', blocks_add_xx_0, '1']
- [low_pass_filter_0, '0', blocks_throttle2_0, '0']
- [mmse_resampler_xx_0, '0', blocks_multiply_xx_0, '0']
- [virtual_source_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0_0, '0', adapt_fo_lms_filter_cc_0, '1']
- [virtual_source_0_0_0, '0', blocks_delay_0_0, '0']
- [virtual_source_0_1, '0', adapt_lms_filter_xx_0, '1']
- [virtual_source_0_1_0, '0', adapt_fo_lms_filter_cc_0, '0']
- [virtual_source_0_1_0_0, '0', adapt_lms_filter_xx_0, '0']
- [virtual_source_0_1_0_0_0, '0', qtgui_freq_sink_x_0, '1']
- [virtual_source_0_1_0_0_0_0, '0', qtgui_freq_sink_x_0, '2']
- [virtual_source_0_1_0_0_0_0_0, '0', qtgui_freq_sink_x_0, '3']
- [virtual_source_0_2, '0', qtgui_number_sink_0, '0']
- [virtual_source_0_2_0, '0', qtgui_number_sink_0, '1']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-991-g721e477c
