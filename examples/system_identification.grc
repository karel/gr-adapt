options:
  parameters:
    author: karel
    description: This example demonstrates how to adaptively estimate the system for a noisy input signal using different adaptive filters.
    generate_options: qt_gui
    id: system_identification
    output_language: python
    title: System Identification with Adaptive Filters
  states: {}

blocks:
- name: frequency
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Frequency
    min_len: '10'
    orient: Qt.Horizontal
    start: 1e3
    step: 1e3
    stop: 1e4
    value: 1e3
  states: {}
- name: gui_adapt
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 2,1,1,1
    label: Adapt
    'true': 'True'
    type: bool
    value: 'True'
  states: {}
- name: gui_delta
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,2
    label: Delta
    min_len: '300'
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '300'
    value: '1'
  states: {}
- name: gui_lambda
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,2
    label: Lambda
    min_len: '100'
    orient: Qt.Horizontal
    start: '0.01'
    step: '0.01'
    stop: '1'
    value: '1'
  states: {}
- name: gui_lms_mu
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: LMS Mu
    min_len: '100'
    orient: Qt.Horizontal
    start: '0.001'
    step: '0.01'
    stop: '1'
    value: '0.01'
  states: {}
- name: gui_nlms_mu
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: NLMS Mu
    min_len: '100'
    orient: Qt.Horizontal
    start: '0.001'
    step: '0.01'
    stop: '2'
    value: '1'
  states: {}
- name: gui_reset
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 2,2,1,1
    label: Reset
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: n_taps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: adapt_lms_filter_xx_1
  id: adapt_lms_filter_xx
  parameters:
    adapt: 'True'
    bypass: 'False'
    decimation: '1'
    filtered_input: 'True'
    first_input: 'True'
    mu: gui_lms_mu
    num_taps: n_taps
    reset: 'False'
    skip: '0'
    type: ff
  states: {}
- name: adapt_nlms_filter_xx_1
  id: adapt_nlms_filter_xx
  parameters:
    adapt: 'True'
    bypass: 'False'
    decimation: '1'
    filtered_input: 'True'
    first_input: 'True'
    mu: gui_nlms_mu
    num_taps: n_taps
    reset: 'False'
    skip: '0'
    type: ff
  states: {state: disabled}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: frequency
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    comment: Adaptive filter will find these taps.
    decim: '1'
    taps: '[1, 0.5, 0.3, 0.9]'
    type: fff
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    color1: '"blue"'
    color2: '"red"'
    color3: '"green"'
    color4: '"black"'
    gui_hint: 6,0,3,3
    label1: Signal
    label2: Filtered Signal
    label3: Adaptive Signal
    label4: Adaptive Error
    nconnections: '4'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    gui_hint: 3,0,3,3
    showports: 'True'
    vlen: n_taps
    x_start: '0'
    x_step: '1.0'
    ymax: '1'
    ymin: '-1'
  states: {}

connections:
- [adapt_lms_filter_xx_1, '0', qtgui_time_sink_x_0, '2']
- [adapt_lms_filter_xx_1, '1', qtgui_time_sink_x_0, '3']
- [adapt_lms_filter_xx_1, '2', qtgui_vector_sink_f_0, '0']
- [adapt_nlms_filter_xx_1, '0', qtgui_time_sink_x_0, '2']
- [adapt_nlms_filter_xx_1, '1', qtgui_time_sink_x_0, '3']
- [adapt_nlms_filter_xx_1, '2', qtgui_vector_sink_f_0, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', adapt_lms_filter_xx_1, '1']
- [blocks_throttle_0, '0', adapt_nlms_filter_xx_1, '1']
- [blocks_throttle_0, '0', fir_filter_xxx_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [fir_filter_xxx_0, '0', adapt_lms_filter_xx_1, '0']
- [fir_filter_xxx_0, '0', adapt_nlms_filter_xx_1, '0']
- [fir_filter_xxx_0, '0', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
