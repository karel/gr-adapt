options:
  parameters:
    author: karel
    description: This example demonstrates how to apply adaptive filters for signal separation using a structure called an adaptive line enhancer.
    generate_options: qt_gui
    id: adaptive_line_enhancer
    output_language: python
    title: Adaptive Line Enhancer
  states: {}

blocks:
- name: frequency
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Frequency
    min_len: '10'
    orient: Qt.Horizontal
    start: 1e3
    step: 1e3
    stop: 1e4
    value: 2e3
  states: {}
- name: gui_adapt
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 2,1,1,1
    label: Adapt
    'true': 'True'
    type: bool
    value: 'True'
  states: {}
- name: gui_delay
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,2
    label: Delay
    min_len: '100'
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '100'
    value: '1'
  states: {}
- name: gui_lms_mu
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: LMS Mu
    min_len: '100'
    orient: Qt.Horizontal
    start: '0.00001'
    step: '0.00001'
    stop: '1'
    value: '0.00001'
  states: {}
- name: gui_noise_amplitude
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: Noise
    min_len: '100'
    orient: Qt.Horizontal
    start: '0.001'
    step: '0.001'
    stop: '1'
    value: '0.03'
  states: {}
- name: gui_reset
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 2,2,1,1
    label: Reset
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: n_taps
  id: variable
  parameters:
    value: '128'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: adapt_lms_filter_xx_0
  id: adapt_lms_filter_xx
  parameters:
    adapt: 'True'
    bypass: 'False'
    decimation: '1'
    filtered_input: 'True'
    first_input: 'True'
    mu: gui_lms_mu
    num_taps: n_taps
    reset: 'False'
    skip: '0'
    type: ff
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: gui_noise_amplitude
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: frequency
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: gui_delay
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: 7,0,3,3
    label1: Input
    label2: Output
    label3: Error
    nconnections: '3'
    showports: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 3,0,3,3
    label1: Input
    label2: Output
    label3: Error
    nconnections: '3'
    size: '512'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    gui_hint: 3,0,3,3
    showports: 'True'
    vlen: n_taps
    x_start: '0'
    x_step: '1.0'
    ymax: '1'
    ymin: '-1'
  states: {state: disabled}

connections:
- [adapt_lms_filter_xx_0, '0', qtgui_freq_sink_x_0, '1']
- [adapt_lms_filter_xx_0, '0', qtgui_time_sink_x_0, '1']
- [adapt_lms_filter_xx_0, '1', qtgui_freq_sink_x_0, '2']
- [adapt_lms_filter_xx_0, '1', qtgui_time_sink_x_0, '2']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_delay_0, '0', adapt_lms_filter_xx_0, '0']
- [blocks_throttle_0, '0', adapt_lms_filter_xx_0, '1']
- [blocks_throttle_0, '0', blocks_delay_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
