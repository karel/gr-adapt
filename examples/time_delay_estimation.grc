options:
  parameters:
    author: karel
    description: This example demonstrates how to adaptively estimate the time delay for a noisy input signal using different adaptive filters. The peak in the filter taps indicates the time delay estimate.
    generate_options: qt_gui
    id: time_delay_estimation
    output_language: python
    title: Time Delay Estimation with Adaptive Filters
  states: {}

blocks:
- name: delay
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,1,1,2
    label: Delay
    min_len: n_taps
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: n_taps
    value: '0'
  states: {}
- name: frequency
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Frequency
    min_len: '10'
    orient: Qt.Horizontal
    start: 1e5
    step: 1e5
    stop: 10e5
    value: 1e5
  states: {}
- name: gui_adapt
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 2,1,1,1
    label: Adapt
    'true': 'True'
    type: bool
    value: 'True'
  states: {}
- name: gui_delta
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,2
    label: Delta
    min_len: '300'
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '300'
    value: '1'
  states: {}
- name: gui_lambda
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,2
    label: Lambda
    min_len: '100'
    orient: Qt.Horizontal
    start: '0.01'
    step: '0.01'
    stop: '1'
    value: '0.99'
  states: {}
- name: gui_lms_mu
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: LMS Mu
    min_len: '100'
    orient: Qt.Horizontal
    start: '0.001'
    step: '0.01'
    stop: '1'
    value: '0.01'
  states: {}
- name: gui_nlms_mu
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: NLMS Mu
    min_len: '100'
    orient: Qt.Horizontal
    start: '0.001'
    step: '0.01'
    stop: '2'
    value: '1'
  states: {}
- name: gui_reset
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 2,2,1,1
    label: Reset
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: n_taps
  id: variable
  parameters:
    value: '16'
  states: {}
- name: phase_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,1
    label: Phase Offset
    min_len: '360'
    orient: Qt.Horizontal
    rangeType: int
    start: '1'
    step: '1'
    stop: '360'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: adapt_lms_filter_xx_1
  id: adapt_lms_filter_xx
  parameters:
    adapt: 'True'
    bypass: 'False'
    decimation: '1'
    filtered_input: 'True'
    first_input: 'True'
    mu: gui_lms_mu
    num_taps: n_taps
    reset: 'False'
    skip: '0'
    type: cc
  states: {}
- name: adapt_nlms_filter_xx_0
  id: adapt_nlms_filter_xx
  parameters:
    adapt: gui_adapt
    bypass: 'False'
    decimation: '1'
    filtered_input: 'True'
    first_input: 'True'
    mu: gui_nlms_mu
    num_taps: n_taps
    reset: gui_reset
    skip: '0'
    type: cc
  states: {state: disabled}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.1'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: frequency
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters:
    vlen: n_taps
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay
    type: complex
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: complex(math.cos(phase_offset*2*math.pi/360), math.sin(phase_offset*2*math.pi/360))
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    color1: '"blue"'
    color2: '"red"'
    color3: '"green"'
    color4: '"black"'
    color5: '"cyan"'
    color6: '"magenta"'
    color7: '"yellow"'
    color8: '"dark red"'
    gui_hint: 7,0,3,3
    label1: Re(Input)
    label2: Im(Input)
    label3: Re(Reference)
    label4: Im(Reference)
    label5: Re(Filtered)
    label6: Im(Filtered)
    label7: Re(Error)
    label8: Im(Error)
    nconnections: '4'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    gui_hint: 4,0,3,3
    label1: Re(Taps)
    label2: Im(Taps)
    nconnections: '2'
    showports: 'True'
    vlen: n_taps
    x_start: '0'
    x_step: '1.0'
    ymax: '1'
    ymin: '-1'
  states: {}

connections:
- [adapt_lms_filter_xx_1, '0', qtgui_time_sink_x_0, '2']
- [adapt_lms_filter_xx_1, '1', qtgui_time_sink_x_0, '3']
- [adapt_lms_filter_xx_1, '2', blocks_complex_to_float_0, '0']
- [adapt_nlms_filter_xx_0, '0', qtgui_time_sink_x_0, '2']
- [adapt_nlms_filter_xx_0, '1', qtgui_time_sink_x_0, '3']
- [adapt_nlms_filter_xx_0, '2', blocks_complex_to_float_0, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_complex_to_float_0, '1', qtgui_vector_sink_f_0, '1']
- [blocks_delay_0, '0', blocks_multiply_const_xx_0, '0']
- [blocks_multiply_const_xx_0, '0', adapt_lms_filter_xx_1, '0']
- [blocks_multiply_const_xx_0, '0', adapt_nlms_filter_xx_0, '0']
- [blocks_multiply_const_xx_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_throttle_0, '0', adapt_lms_filter_xx_1, '1']
- [blocks_throttle_0, '0', adapt_nlms_filter_xx_0, '1']
- [blocks_throttle_0, '0', blocks_delay_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
