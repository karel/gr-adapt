<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>time_delay_estimation</value></param>
<param><key>author</key><value>karel</value></param>
<param><key>description</key><value>This example demonstrates how to adaptively estimate the time delay for a noisy input signal using different adaptive filters. The peak in the filter taps indicates the time delay estimate.</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Time Delay Estimation with Adaptive Filters</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>delay</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>3,1,1,2</value></param>
<param><key>label</key><value>Delay</value></param>
<param><key>min_len</key><value>n_taps</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>n_taps</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>frequency</value></param>
<param><key>value</key><value>1e5</value></param>
<param><key>gui_hint</key><value>2,0,1,1</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>min_len</key><value>10</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1e5</value></param>
<param><key>step</key><value>1e5</value></param>
<param><key>stop</key><value>10e5</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>gui_adapt</value></param>
<param><key>value</key><value>True</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>2,1,1,1</value></param>
<param><key>label</key><value>Adapt</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>bool</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gui_delta</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>0,1,1,2</value></param>
<param><key>label</key><value>Delta</value></param>
<param><key>min_len</key><value>300</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>300</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gui_lambda</value></param>
<param><key>value</key><value>0.99</value></param>
<param><key>gui_hint</key><value>1,1,1,2</value></param>
<param><key>label</key><value>Lambda</value></param>
<param><key>min_len</key><value>100</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.01</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gui_lms_mu</value></param>
<param><key>value</key><value>0.01</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label</key><value>LMS Mu</value></param>
<param><key>min_len</key><value>100</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.001</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gui_nlms_mu</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>label</key><value>NLMS Mu</value></param>
<param><key>min_len</key><value>100</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0.001</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>2</value></param>
</block>
<block>
<key>variable_qtgui_check_box</key>
<param><key>id</key><value>gui_reset</value></param>
<param><key>value</key><value>False</value></param>
<param><key>false</key><value>False</value></param>
<param><key>gui_hint</key><value>2,2,1,1</value></param>
<param><key>label</key><value>Reset</value></param>
<param><key>true</key><value>True</value></param>
<param><key>type</key><value>bool</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>n_taps</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>phase_offset</value></param>
<param><key>value</key><value>1</value></param>
<param><key>gui_hint</key><value>3,0,1,1</value></param>
<param><key>label</key><value>Phase Offset</value></param>
<param><key>min_len</key><value>360</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>360</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>adapt_iqrd_rls_filter_xx</key>
<param><key>id</key><value>adapt_iqrd_rls_filter_xx_0</value></param>
<param><key>adapt</key><value>gui_adapt</value></param>
<param><key>decimation</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>num_taps</key><value>n_taps</value></param>
<param><key>reset</key><value>gui_reset</value></param>
<param><key>skip</key><value>0</value></param>
<param><key>type</key><value>cc</value></param>
<param><key>delta</key><value>gui_delta</value></param>
<param><key>lambda</key><value>gui_lambda</value></param>
</block>
<block>
<key>adapt_lms_filter_xx</key>
<param><key>id</key><value>adapt_lms_filter_xx_0</value></param>
<param><key>adapt</key><value>gui_adapt</value></param>
<param><key>decimation</key><value>1</value></param>
<param><key>first_input</key><value>True</value></param>
<param><key>num_taps</key><value>n_taps</value></param>
<param><key>reset</key><value>gui_reset</value></param>
<param><key>skip</key><value>0</value></param>
<param><key>type</key><value>cc</value></param>
<param><key>mu</key><value>gui_lms_mu</value></param>
</block>
<block>
<key>adapt_nlms_filter_xx</key>
<param><key>id</key><value>adapt_nlms_filter_xx_0</value></param>
<param><key>adapt</key><value>gui_adapt</value></param>
<param><key>decimation</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>first_input</key><value>True</value></param>
<param><key>num_taps</key><value>n_taps</value></param>
<param><key>reset</key><value>gui_reset</value></param>
<param><key>skip</key><value>0</value></param>
<param><key>type</key><value>cc</value></param>
<param><key>mu</key><value>gui_nlms_mu</value></param>
</block>
<block>
<key>adapt_qrd_rls_filter_xx</key>
<param><key>id</key><value>adapt_qrd_rls_filter_xx_0</value></param>
<param><key>adapt</key><value>gui_adapt</value></param>
<param><key>decimation</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>num_taps</key><value>n_taps</value></param>
<param><key>reset</key><value>gui_reset</value></param>
<param><key>skip</key><value>0</value></param>
<param><key>type</key><value>cc</value></param>
<param><key>delta</key><value>gui_delta</value></param>
<param><key>lambda</key><value>gui_lambda</value></param>
</block>
<block>
<key>adapt_rls_filter_xx</key>
<param><key>id</key><value>adapt_rls_filter_xx_0</value></param>
<param><key>adapt</key><value>gui_adapt</value></param>
<param><key>decimation</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>first_input</key><value>True</value></param>
<param><key>num_taps</key><value>n_taps</value></param>
<param><key>reset</key><value>gui_reset</value></param>
<param><key>skip</key><value>0</value></param>
<param><key>type</key><value>cc</value></param>
<param><key>delta</key><value>gui_delta</value></param>
<param><key>lambda</key><value>gui_lambda</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>amp</key><value>0.1</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>frequency</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
<param><key>vlen</key><value>n_taps</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>delay</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_xx</key>
<param><key>id</key><value>blocks_multiply_const_xx_0</value></param>
<param><key>const</key><value>complex(math.cos(phase_offset*2*math.pi/360), math.sin(phase_offset*2*math.pi/360))</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>gui_hint</key><value>7,0,3,3</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Re(Input)</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>Im(Input)</value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value>Re(Reference)</value></param>
<param><key>color4</key><value>"black"</value></param>
<param><key>label4</key><value>Im(Reference)</value></param>
<param><key>color5</key><value>"cyan"</value></param>
<param><key>label5</key><value>Re(Filtered)</value></param>
<param><key>color6</key><value>"magenta"</value></param>
<param><key>label6</key><value>Im(Filtered)</value></param>
<param><key>color7</key><value>"yellow"</value></param>
<param><key>label7</key><value>Re(Error)</value></param>
<param><key>color8</key><value>"dark red"</value></param>
<param><key>label8</key><value>Im(Error)</value></param>
<param><key>nconnections</key><value>4</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_vector_sink_f</key>
<param><key>id</key><value>qtgui_vector_sink_f_0</value></param>
<param><key>gui_hint</key><value>4,0,3,3</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>label1</key><value>Re(Taps)</value></param>
<param><key>label2</key><value>Im(Taps)</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>vlen</key><value>n_taps</value></param>
<param><key>x_start</key><value>0</value></param>
<param><key>x_step</key><value>1.0</value></param>
<param><key>ymax</key><value>1</value></param>
<param><key>ymin</key><value>-1</value></param>
</block>
<connection><source_block_id>adapt_iqrd_rls_filter_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>adapt_iqrd_rls_filter_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>adapt_iqrd_rls_filter_xx_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>adapt_lms_filter_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>adapt_lms_filter_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>adapt_lms_filter_xx_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>adapt_nlms_filter_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>adapt_nlms_filter_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>adapt_nlms_filter_xx_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>adapt_qrd_rls_filter_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>adapt_qrd_rls_filter_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>adapt_qrd_rls_filter_xx_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>adapt_rls_filter_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>adapt_rls_filter_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>adapt_rls_filter_xx_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>qtgui_vector_sink_f_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_multiply_const_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_xx_0</source_block_id><sink_block_id>adapt_iqrd_rls_filter_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_xx_0</source_block_id><sink_block_id>adapt_lms_filter_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_xx_0</source_block_id><sink_block_id>adapt_nlms_filter_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_xx_0</source_block_id><sink_block_id>adapt_qrd_rls_filter_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_xx_0</source_block_id><sink_block_id>adapt_rls_filter_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>adapt_iqrd_rls_filter_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>adapt_lms_filter_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>adapt_nlms_filter_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>adapt_qrd_rls_filter_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>adapt_rls_filter_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
