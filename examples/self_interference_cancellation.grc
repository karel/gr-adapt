options:
  parameters:
    author: karel
    description: This example demonstrates how to adaptively cancel self-interference.
    generate_options: qt_gui
    id: self_interference_cancellation
    output_language: python
    title: Self-Interference Cancellation with Adaptive Filters
  states: {}

blocks:
- name: gui_adapt
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 2,1,1,1
    label: Adapt
    'true': 'True'
    type: bool
    value: 'True'
  states: {}
- name: gui_amplitude_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,1,1,1
    label: Amplitude 1
    min_len: '10'
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '1'
  states: {}
- name: gui_amplitude_2
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,2,1,1
    label: Amplitude 2
    min_len: '10'
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '1'
  states: {}
- name: gui_delta
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,2
    label: Delta
    min_len: '300'
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '300'
    value: '1'
  states: {}
- name: gui_frequency_1
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: Frequency 1
    min_len: '10'
    orient: Qt.Horizontal
    start: 1e3
    step: 1e3
    stop: 1e4
    value: 1e3
  states: {}
- name: gui_frequency_2
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,1
    label: Frequency 2
    min_len: '10'
    orient: Qt.Horizontal
    start: 1e3
    step: 1e3
    stop: 1e4
    value: 2e3
  states: {}
- name: gui_lambda
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,2
    label: Lambda
    min_len: '100'
    orient: Qt.Horizontal
    start: '0.01'
    step: '0.01'
    stop: '1'
    value: '1'
  states: {}
- name: gui_lms_mu
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: LMS Mu
    min_len: '100'
    orient: Qt.Horizontal
    start: '0.001'
    step: '0.01'
    stop: '1'
    value: '0.01'
  states: {}
- name: gui_nlms_mu
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: NLMS Mu
    min_len: '100'
    orient: Qt.Horizontal
    start: '0.001'
    step: '0.01'
    stop: '2'
    value: '1'
  states: {}
- name: gui_reset
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    gui_hint: 2,2,1,1
    label: Reset
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: n_taps
  id: variable
  parameters:
    value: '16'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: adapt_lms_filter_xx_1
  id: adapt_lms_filter_xx
  parameters:
    adapt: 'True'
    bypass: 'False'
    decimation: '1'
    filtered_input: 'True'
    first_input: 'True'
    mu: gui_lms_mu
    num_taps: n_taps
    reset: 'False'
    skip: '0'
    type: ff
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.001'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: gui_amplitude_1
    freq: gui_frequency_1
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: gui_amplitude_2
    freq: gui_frequency_2
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: '[1, 0.5, 0.3, 0.9]'
    type: fff
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: Error signal is the output without self-interference.
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: 7,0,3,3
    label1: Input
    label2: Reference
    label3: Out
    label4: Error
    nconnections: '4'
    showports: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    gui_hint: 4,0,3,3
    showports: 'True'
    vlen: n_taps
    x_start: '0'
    x_step: '1.0'
    ymax: '1'
    ymin: '-1'
  states: {}

connections:
- [adapt_lms_filter_xx_1, '0', qtgui_freq_sink_x_0, '2']
- [adapt_lms_filter_xx_1, '1', qtgui_freq_sink_x_0, '3']
- [adapt_lms_filter_xx_1, '2', qtgui_vector_sink_f_0, '0']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0, '0', adapt_lms_filter_xx_1, '1']
- [analog_sig_source_x_0, '0', fir_filter_xxx_0, '0']
- [analog_sig_source_x_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_sig_source_x_1, '0', blocks_throttle_0, '0']
- [blocks_add_xx_0, '0', adapt_lms_filter_xx_1, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_throttle_0, '0', blocks_add_xx_0, '1']
- [fir_filter_xxx_0, '0', blocks_add_xx_0, '2']

metadata:
  file_format: 1
