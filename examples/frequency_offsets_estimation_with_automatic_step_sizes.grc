options:
  parameters:
    author: karel
    description: This example demonstrates the use of VSS-FO-LMS adaptive filter.
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: frequency_offsets_estimation_with_variable_step_sizes
    output_language: python
    title: Frequency Offsets Estimaton
  states: {}

blocks:
- name: F_cfo
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,3
    label: F_cfo
    min_len: '10'
    start: '-1e3'
    step: 1e3
    stop: 1e3
    value: '0'
  states: {}
- name: F_sfo
  id: variable_qtgui_range
  parameters:
    gui_hint: 4,0,1,3
    label: F_sfo
    min_len: '10'
    start: '-.1'
    step: '.01'
    stop: '.1'
    value: '0'
  states: {}
- name: gui_lambda_R
  id: variable_qtgui_range
  parameters:
    label: '"\u03BB_R"'
    min_len: '100'
    start: '0.9'
    step: '0.0001'
    stop: '0.9999999'
    value: '0.95'
  states: {}
- name: gui_lambda_e
  id: variable_qtgui_range
  parameters:
    label: '"\u03BB_e"'
    min_len: '100'
    start: '0.9'
    step: '0.0001'
    stop: '0.9999999'
    value: '0.9999'
  states: {}
- name: gui_lambda_epsilon
  id: variable_qtgui_range
  parameters:
    label: '"\u03BB_\u03B5"'
    min_len: '100'
    start: '0.9'
    step: '0.0001'
    stop: '0.9999999'
    value: '0.95'
  states: {}
- name: gui_lambda_eta
  id: variable_qtgui_range
  parameters:
    label: '"\u03BB_\u03B7"'
    min_len: '100'
    start: '0.9'
    step: '0.0001'
    stop: '0.9999999'
    value: '0.95'
  states: {}
- name: gui_lambda_y
  id: variable_qtgui_range
  parameters:
    label: '"\u03BB_y"'
    min_len: '100'
    start: '0.9'
    step: '0.0001'
    stop: '0.9999999'
    value: '0.99'
  states: {}
- name: gui_measurement_noise_known
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    label: Measurement noise known?
    'true': 'True'
    type: bool
    value: 'True'
  states: {}
- name: gui_mu_cfo
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: '"CFO \u03BC"'
    min_len: '100'
    start: '0.0'
    step: '0.01'
    stop: '.01'
    value: '0.0'
  states: {}
- name: gui_mu_cir
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: '"CIR \u03BC"'
    min_len: '100'
    start: '0.00001'
    step: '0.0001'
    stop: '1'
    value: '0.05'
  states: {}
- name: gui_mu_sfo
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,2,1,1
    label: '"SFO \u03BC"'
    min_len: '100'
    start: '0.0'
    step: '0.01'
    stop: '.01'
    value: '0.0'
  states: {}
- name: gui_sigma2_q
  id: variable_qtgui_range
  parameters:
    label: '"\u03C3^2_q [dBw]"'
    min_len: '100'
    start: '-150'
    step: '0.01'
    stop: '0'
    value: '-130'
  states: {}
- name: gui_sigma2_s
  id: variable_qtgui_range
  parameters:
    label: '"\u03C3^2_s [dBw]"'
    min_len: '100'
    start: '-100'
    step: '0.01'
    stop: '0'
    value: '-100'
  states: {}
- name: gui_sigma2_v
  id: variable_qtgui_range
  parameters:
    label: '"\u03C3^2_v [dBw]"'
    min_len: '100'
    start: '-100'
    step: '0.01'
    stop: '0'
    value: '-60'
  states: {}
- name: n_taps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '512000'
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,0,1,3
    label: Step sizes
    type: string
    value: ''
  states: {}
- name: variable_qtgui_label_1
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,0,1,3
    label: Frequency offsets
    type: string
    value: ''
  states: {}
- name: variable_qtgui_label_2
  id: variable_qtgui_label
  parameters:
    gui_hint: 5,0,1,3
    label: FO-LMS Estimates
    type: string
    value: ''
  states: {}
- name: variable_qtgui_label_2_0
  id: variable_qtgui_label
  parameters:
    gui_hint: 7,0,1,3
    label: Controls
    type: string
    value: ''
  states: {}
- name: variable_qtgui_label_2_1
  id: variable_qtgui_label
  parameters:
    label: VSS-FO-LMS Estimates
    type: string
    value: ''
  states: {}
- name: variable_qtgui_label_3
  id: variable_qtgui_label
  parameters:
    gui_hint: 9,0,1,3
    label: Power spectral density
    type: string
    value: ''
  states: {}
- name: variable_qtgui_push_button_reset_folms
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 8,1,1,1
    label: Reset (FO-LMS)
    pressed: 'True'
    released: 'False'
    type: bool
    value: 'False'
  states: {}
- name: variable_qtgui_push_button_reset_lms
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 8,0,1,1
    label: Reset (LMS)
    pressed: 'True'
    released: 'False'
    type: bool
    value: 'False'
  states: {}
- name: variable_qtgui_push_button_reset_vssfolms
  id: variable_qtgui_push_button
  parameters:
    gui_hint: 8,2,1,1
    label: Reset (VSS-FO-LMS)
    pressed: 'True'
    released: 'False'
    type: bool
    value: 'False'
  states: {}
- name: adapt_fo_lms_filter_cc_0
  id: adapt_fo_lms_filter_cc
  parameters:
    adapt: 'True'
    mu_cfo: gui_mu_cfo
    mu_cir: gui_mu_cir
    mu_sfo: gui_mu_sfo
    num_taps: n_taps
    reset: variable_qtgui_push_button_reset_folms
    samp_rate: samp_rate
  states: {}
- name: adapt_lms_filter_xx_0
  id: adapt_lms_filter_xx
  parameters:
    adapt: 'True'
    bypass: 'False'
    decimation: '1'
    filtered_input: 'True'
    first_input: 'True'
    mu: gui_mu_cir
    num_taps: n_taps
    reset: variable_qtgui_push_button_reset_lms
    skip: '0'
    type: cc
  states: {}
- name: adapt_vss_fo_lms_filter_cc_0
  id: adapt_vss_fo_lms_filter_cc
  parameters:
    adapt: 'True'
    lambda_R: gui_lambda_R
    lambda_e: gui_lambda_e
    lambda_epsilon: gui_lambda_epsilon
    lambda_eta: gui_lambda_eta
    lambda_y: gui_lambda_y
    num_taps: n_taps
    reset: variable_qtgui_push_button_reset_vssfolms
    samp_rate: samp_rate
    sigma2_v: (10 ** (gui_sigma2_v*1/10)) if gui_measurement_noise_known else 0.0
    step_size_limits: '[1e-8, 1e-1, 1e-9, 1e-3, 1e-9, 1e-3]'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: np.sqrt(1)
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_noise_source_x_0_0
  id: analog_noise_source_x
  parameters:
    amp: np.sqrt(10 ** (gui_sigma2_v/10))
    noise_type: analog.GR_GAUSSIAN
    seed: '27'
    type: complex
  states: {}
- name: analog_noise_source_x_0_0_0
  id: analog_noise_source_x
  parameters:
    amp: np.sqrt(10 ** (gui_sigma2_s/10))
    noise_type: analog.GR_GAUSSIAN
    seed: '31'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: Carrier frequency offset.
    freq: F_cfo
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    comment: This delay is required because of the following fractional resampler.
    delay: '3'
    type: complex
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '4000'
    scale: 1/1000
    type: float
  states: {state: disabled}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '4000'
    scale: 1/1000
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: samp_rate / (2 * np.pi)
    mode: vector
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    mode: vector
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    mode: vector
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: samp_rate / (2 * np.pi)
    mode: vector
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_nlog10_ff_1
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_sub_xx_0_1
  id: blocks_sub_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      First order auto-regressive channel model.:

      This implements a simple AR(1) channel model, where each tap varies with variance sigma2_q.

      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """Embedded Python Block for AR(1) Channel Model - each tap varies with variance sigma2_q"""

          def __init__(self, taps=[1 + 0j, 0 + 0j], alpha=0.9999, sigma2_q=1e-10):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='AR(1) Channel Model',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )

              self.taps = taps
              self.M = len(self.taps)
              self.alpha = alpha
              self.sigma2_q = sigma2_q

              self.theta = np.zeros(self.M, dtype=np.complex64)
              self.history = np.zeros(self.M-1, dtype=np.complex64)

          def work(self, input_items, output_items):
              N = len(input_items[0])
              in0 = np.concatenate((self.history, input_items[0]))

              q = np.random.normal(0, np.sqrt(self.sigma2_q), (N, self.M)) + 1j * np.random.normal(0, np.sqrt(self.sigma2_q), (N, self.M))
              for n in range(N):
                  self.theta = self.alpha * self.theta + q[n, :]
                  taps = self.taps + self.theta
                  output_items[0][n] = np.vdot(taps, in0[n:n+self.M])
              self.history = in0[-(self.M-1):]
              return N
    alpha: '0.9999'
    sigma2_q: (10 ** (gui_sigma2_q/10))
    taps: '[1.2-1j, 0.5+0.3j, 0.3+0.4j]'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: samp_rate / 4
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: samp_rate / 50
    win: window.WIN_HAMMING
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    comment: Sampling frequency offset.
    phase_shift: '0'
    resamp_ratio: samp_rate / (samp_rate + F_sfo)
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 10,0,10,3
    label1: '''Transmitted (x)'''
    label2: '''Received (d)'''
    label3: '''Measurement Noise (v)'''
    label4: '''\u03B6 LMS'''
    label5: '''\u03B6 FO-LMS'''
    label6: '''\u03B6 VSS-FO-LMS'''
    nconnections: '6'
    type: complex
    ymin: '-160'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    avg: '.7'
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: 6,0,1,3
    label1: F_cfo
    label2: F_sfo
    max: + samp_rate / 2
    min: '- samp_rate / 2'
    name: ''
    nconnections: '2'
    type: float
    unit1: Hz
    unit2: Hz
  states: {}
- name: qtgui_number_sink_0_0_0_0
  id: qtgui_number_sink
  parameters:
    avg: '1'
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: noise!
    max: '0'
    min: '-140'
    name: ''
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    avg: '.7'
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: F_cfo
    label2: F_sfo
    label3: Noise
    max: + samp_rate / 2
    min: '- samp_rate / 2'
    name: ''
    nconnections: '3'
    type: float
    unit1: Hz
    unit2: Hz
    unit3: dBw
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    comment: Known transmitted signal.
    stream_id: x
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    comment: Received signal.
    stream_id: d
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    comment: Measurement noise.
    stream_id: v
  states: {}
- name: virtual_sink_0_0_0_0
  id: virtual_sink
  parameters:
    comment: Background signal.
    stream_id: s
  states: {}
- name: virtual_sink_0_1
  id: virtual_sink
  parameters:
    stream_id: fo-lms-error
  states: {}
- name: virtual_sink_0_1_0
  id: virtual_sink
  parameters:
    stream_id: lms-error
  states: {}
- name: virtual_sink_0_1_0_0
  id: virtual_sink
  parameters:
    stream_id: f_cfo-est
  states: {}
- name: virtual_sink_0_1_0_0_0
  id: virtual_sink
  parameters:
    stream_id: f_sfo-est
  states: {}
- name: virtual_sink_0_1_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: f_sfo-est-vss
  states: {}
- name: virtual_sink_0_1_0_0_0_0_0
  id: virtual_sink
  parameters:
    stream_id: noise-est-vss
  states: {}
- name: virtual_sink_0_1_0_0_1
  id: virtual_sink
  parameters:
    stream_id: f_cfo-est-vss
  states: {}
- name: virtual_sink_0_1_1
  id: virtual_sink
  parameters:
    stream_id: vss-fo-lms-error
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: x
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: x
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    comment: Known transmitted signal.
    stream_id: x
  states: {}
- name: virtual_source_0_0_1
  id: virtual_source
  parameters:
    stream_id: x
  states: {}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: x
  states: {}
- name: virtual_source_0_1_0
  id: virtual_source
  parameters:
    stream_id: d
  states: {}
- name: virtual_source_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: d
  states: {}
- name: virtual_source_0_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: d
  states: {}
- name: virtual_source_0_1_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: lms-error
  states: {}
- name: virtual_source_0_1_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: fo-lms-error
  states: {}
- name: virtual_source_0_1_0_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: vss-fo-lms-error
  states: {}
- name: virtual_source_0_1_0_1
  id: virtual_source
  parameters:
    stream_id: d
  states: {}
- name: virtual_source_0_1_0_1_0
  id: virtual_source
  parameters:
    stream_id: v
  states: {state: disabled}
- name: virtual_source_0_1_0_1_0_0
  id: virtual_source
  parameters:
    stream_id: v
  states: {}
- name: virtual_source_0_1_0_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: v
  states: {}
- name: virtual_source_0_1_0_1_0_0_1
  id: virtual_source
  parameters:
    stream_id: v
  states: {}
- name: virtual_source_0_1_0_1_0_0_2
  id: virtual_source
  parameters:
    stream_id: s
  states: {}
- name: virtual_source_0_1_0_1_0_0_2_0
  id: virtual_source
  parameters:
    stream_id: s
  states: {}
- name: virtual_source_0_1_0_1_0_0_2_1
  id: virtual_source
  parameters:
    stream_id: s
  states: {}
- name: virtual_source_0_1_0_1_0_1
  id: virtual_source
  parameters:
    stream_id: v
  states: {}
- name: virtual_source_0_2
  id: virtual_source
  parameters:
    stream_id: f_cfo-est
  states: {}
- name: virtual_source_0_2_0
  id: virtual_source
  parameters:
    stream_id: f_sfo-est
  states: {}
- name: virtual_source_0_2_0_0
  id: virtual_source
  parameters:
    stream_id: f_sfo-est-vss
  states: {}
- name: virtual_source_0_2_0_0_0
  id: virtual_source
  parameters:
    stream_id: noise-est-vss
  states: {}
- name: virtual_source_0_2_1
  id: virtual_source
  parameters:
    stream_id: f_cfo-est-vss
  states: {}

connections:
- [adapt_fo_lms_filter_cc_0, '0', blocks_null_sink_1, '0']
- [adapt_fo_lms_filter_cc_0, '1', blocks_sub_xx_0, '0']
- [adapt_fo_lms_filter_cc_0, '2', blocks_multiply_const_vxx_0, '0']
- [adapt_fo_lms_filter_cc_0, '3', blocks_multiply_const_vxx_0_0, '0']
- [adapt_lms_filter_xx_0, '0', blocks_null_sink_0, '0']
- [adapt_lms_filter_xx_0, '1', blocks_sub_xx_0_0, '0']
- [adapt_vss_fo_lms_filter_cc_0, '0', blocks_null_sink_1_0, '0']
- [adapt_vss_fo_lms_filter_cc_0, '1', blocks_sub_xx_0_1, '0']
- [adapt_vss_fo_lms_filter_cc_0, '2', blocks_multiply_const_vxx_0_1, '0']
- [adapt_vss_fo_lms_filter_cc_0, '3', blocks_multiply_const_vxx_0_0_0, '0']
- [adapt_vss_fo_lms_filter_cc_0, '4', blocks_moving_average_xx_0_0, '0']
- [analog_noise_source_x_0, '0', low_pass_filter_0, '0']
- [analog_noise_source_x_0_0, '0', blocks_add_xx_0, '0']
- [analog_noise_source_x_0_0, '0', virtual_sink_0_0_0, '0']
- [analog_noise_source_x_0_0_0, '0', blocks_add_xx_0, '2']
- [analog_noise_source_x_0_0_0, '0', virtual_sink_0_0_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_add_xx_0, '0', virtual_sink_0_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_delay_0_0, '0', mmse_resampler_xx_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_nlog10_ff_1, '0']
- [blocks_moving_average_xx_0_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_multiply_const_vxx_0, '0', virtual_sink_0_1_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', virtual_sink_0_1_0_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0, '0', virtual_sink_0_1_0_0_0_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', virtual_sink_0_1_0_0_1, '0']
- [blocks_multiply_xx_0, '0', epy_block_1, '0']
- [blocks_nlog10_ff_0, '0', virtual_sink_0_1_0_0_0_0_0, '0']
- [blocks_nlog10_ff_1, '0', qtgui_number_sink_0_0_0_0, '0']
- [blocks_sub_xx_0, '0', virtual_sink_0_1, '0']
- [blocks_sub_xx_0_0, '0', virtual_sink_0_1_0, '0']
- [blocks_sub_xx_0_1, '0', virtual_sink_0_1_1, '0']
- [blocks_throttle2_0, '0', virtual_sink_0, '0']
- [epy_block_1, '0', blocks_add_xx_0, '1']
- [low_pass_filter_0, '0', blocks_throttle2_0, '0']
- [mmse_resampler_xx_0, '0', blocks_multiply_xx_0, '0']
- [virtual_source_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0_0, '0', adapt_fo_lms_filter_cc_0, '1']
- [virtual_source_0_0_0, '0', blocks_delay_0_0, '0']
- [virtual_source_0_0_1, '0', adapt_vss_fo_lms_filter_cc_0, '1']
- [virtual_source_0_1, '0', adapt_lms_filter_xx_0, '1']
- [virtual_source_0_1_0, '0', adapt_fo_lms_filter_cc_0, '0']
- [virtual_source_0_1_0_0, '0', adapt_lms_filter_xx_0, '0']
- [virtual_source_0_1_0_0_0, '0', qtgui_freq_sink_x_0, '1']
- [virtual_source_0_1_0_0_0_0, '0', qtgui_freq_sink_x_0, '3']
- [virtual_source_0_1_0_0_0_0_0, '0', qtgui_freq_sink_x_0, '4']
- [virtual_source_0_1_0_0_0_0_0_0, '0', qtgui_freq_sink_x_0, '5']
- [virtual_source_0_1_0_1, '0', adapt_vss_fo_lms_filter_cc_0, '0']
- [virtual_source_0_1_0_1_0, '0', blocks_complex_to_mag_squared_0, '0']
- [virtual_source_0_1_0_1_0_0, '0', blocks_sub_xx_0, '1']
- [virtual_source_0_1_0_1_0_0_0, '0', blocks_sub_xx_0_0, '1']
- [virtual_source_0_1_0_1_0_0_1, '0', blocks_sub_xx_0_1, '1']
- [virtual_source_0_1_0_1_0_0_2, '0', blocks_sub_xx_0, '2']
- [virtual_source_0_1_0_1_0_0_2_0, '0', blocks_sub_xx_0_0, '2']
- [virtual_source_0_1_0_1_0_0_2_1, '0', blocks_sub_xx_0_1, '2']
- [virtual_source_0_1_0_1_0_1, '0', qtgui_freq_sink_x_0, '2']
- [virtual_source_0_2, '0', qtgui_number_sink_0, '0']
- [virtual_source_0_2_0, '0', qtgui_number_sink_0, '1']
- [virtual_source_0_2_0_0, '0', qtgui_number_sink_1, '1']
- [virtual_source_0_2_0_0_0, '0', qtgui_number_sink_1, '2']
- [virtual_source_0_2_1, '0', qtgui_number_sink_1, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-1029-g3c48f5e2
